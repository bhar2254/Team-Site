# Autodesk Inventor assembly: roller assembly
## iProperties
Created: 2007-11
Part Number: roller assembly
Document SubType Name: Assembly
Designer: lwoods
Author: lwoods
