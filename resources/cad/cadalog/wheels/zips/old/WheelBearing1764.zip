# Autodesk Inventor assembly: wheel bearing
## iProperties
Created: 2009-01
Part Number: wheel bearing
Document SubType Name: Assembly
Designer: pmulligan
Author: pmulligan
