# Autodesk Inventor part: Gage
## iProperties
Created: 2010-02
Part Number: Gage
Document SubType Name: Modeling
Designer: jgehrig
Density: 1 g/cm^3
Author: jgehrig
## Feature names
1. Extrusion1
