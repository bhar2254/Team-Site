# Autodesk Inventor assembly: Air Release
## iProperties
Created: 2010-02
Part Number: Air Release
Document SubType Name: Assembly
Designer: jgehrig
Author: jgehrig
