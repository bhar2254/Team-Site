# Autodesk Inventor assembly: Bend Piece
## iProperties
Created: 2010-02
Part Number: Bend Piece
Document SubType Name: Assembly
Designer: jgehrig
Author: jgehrig
