# Autodesk Inventor assembly: Regulator
## iProperties
Created: 2010-02
Part Number: Regulator
Document SubType Name: Assembly
Designer: jgehrig
Author: jgehrig
