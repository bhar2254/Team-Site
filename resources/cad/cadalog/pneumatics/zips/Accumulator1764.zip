# Autodesk Inventor assembly: Air Cylinder
## iProperties
Created: 2010-01
Part Number: Air Cylinder
Document SubType Name: Assembly
Designer: cmcfadden
Author: cmcfadden
