# Autodesk Inventor assembly: Joiner Piece
## iProperties
Created: 2010-02
Part Number: Joiner Piece
Document SubType Name: Assembly
Designer: jgehrig
Author: jgehrig
