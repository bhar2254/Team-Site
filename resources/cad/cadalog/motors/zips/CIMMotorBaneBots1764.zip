# Autodesk Inventor assembly: CIM Motor
## iProperties
Created: 2010-01
Part Number: CIM Motor
Document SubType Name: Assembly
Designer: cmcfadden
Author: cmcfadden
