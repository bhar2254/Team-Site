# Autodesk Inventor assembly: Dongle
## iProperties
Created: 2010-01
Part Number: Dongle
Document SubType Name: Weldment
Designer: jgehrig
Weld Material: Welded Aluminum-6061
Author: jgehrig
